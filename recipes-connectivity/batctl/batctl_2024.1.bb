require batctl.inc
PR = "${INC_PR}.0"

SRCREV = "fd6a74d256394a4027a90ae9eda02df4309f21c9"
