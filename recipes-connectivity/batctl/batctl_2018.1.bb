require batctl.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "dd480ae5572c4423913a9c91477ff73d"
SRC_URI[sha256sum] = "27877d0da6916f88a6cecbbb3f3d23cc4558ef7c7294324bf4fd050ed606b553"

