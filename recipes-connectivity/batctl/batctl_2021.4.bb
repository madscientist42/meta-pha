require batctl.inc
PR = "${INC_PR}.0"

SRC_URI[sha256sum] = "b6d96e908e3295a1413e8ec4f0f9851f85c67c752ac45bebbbe58aad40fad8e7"
