# Jethro should support the "right" versions here- make them shared linkage here...
PACKAGECONFIG = "zlib openssl"
