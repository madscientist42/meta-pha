# Declare we're using pha_base, which doesn't use/provide a dev environment
IMG_BASE = "pha-dev-image"

require pha-forensics.inc

