require pha-base-image.bb

IMAGE_INSTALL += " \
    xr819-experimental \
    "