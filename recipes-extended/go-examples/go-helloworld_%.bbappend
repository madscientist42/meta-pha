# Cripple Dynamic Link on at least aarch64 systems- it doesn't work as it should
# right now (Segfaults in a wierd place) 
GO_DYNLINK_aarch64 = ""

