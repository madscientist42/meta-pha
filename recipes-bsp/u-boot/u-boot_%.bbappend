FILESEXTRAPATHS_prepend := "${THISDIR}/files"

SRC_URI += " \
	file://00001-add-nanopi-neo-plus2-support.patch \
	"
