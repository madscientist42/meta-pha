KERNEL_EXTRA_ARGS += "STAGING_LIBDIR_NATIVE=${STAGING_LIBDIR_NATIVE} \
		      STAGING_INCDIR_NATIVE=${STAGING_INCDIR_NATIVE} \
                      LOADADDR=${UBOOT_ENTRYPOINT}"

